Commit message: 1

File: 3/02/urdf/simple_wheel_robot.urdf (robot description, URDF)
Before this commit: robot simple_two_wheel_robot, 3 links, 2 joints
Links:
- removed link left_wheel
- removed link right_wheel
Joints:
- removed joint left_wheel_joint
- removed joint right_wheel_joint
